Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-03-04T11:40:24
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Mar 04 11:40:24 2021 * Host: pr500ssd * Database: C:\Users\PREDRA~1.RAK\AppData\Local\Temp\{511E3508-00AD-4679-90C6-B12DEA661F65}\ifc * Database version: 5507 * Database creation date: Thu Mar 04 11:40:23 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Mar 04 11:40:23 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Mar 04 11:40:23 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowTerminal: 160 x 90, Tus kada_ Stone_cement_rezana_R18:160 x 90:358936
In: Level 1
Material: Bijela Stone
Pset_ManufacturerTypeInformation - Manufacturer: Aquaestil plus d.o.o., Lastovska 12a, 10 000, Zagreb, Hrvatska
Pset_DistributionFlowElementCommon - Reference: Tus kada_ Stone_cement_rezana_R18:160 x 90
Constraints - Debljina voida front: 10 mm; Debljina voida L: 10 mm; Debljina voida R: 10 mm; Host: Level : Level 1; Level: Level: Level 1; Maksimalno rezanje front: 10 mm; Maksimalno rezanje L: 10 mm; Maksimalno rezanje R: 10 mm; Moves With Nearby Elements: no; Offset: 0 mm
Construction - Debljina rezanja front: 0 mm; Debljina rezanja L: 0 mm; Debljina rezanja R: 0 mm
Dimensions - Area: 1.54149 m2; Volume: 0.0351427 m3
Identity Data - Mark: 1
Other - Category: Plumbing Fixtures; Family: Tus kada_ Stone_cement_rezana_R18: 160 x 90; Family and Type: Tus kada_ Stone_cement_rezana_R18: 160 x 90; Type: Tus kada_ Stone_cement_rezana_R18: 160 x 90; Type Id: Tus kada_ Stone_cement_rezana_R18: 160 x 90
Phasing - Phase Created: New Construction
Dimensions(Type) - Dubina A: 1600 mm; Otvor: 125 mm; Sirina B: 900 mm; Zona u kojoj se ne smije rezati: 450 mm
Identity Data(Type) - Manufacturer: Aquaestil plus d.o.o., Lastovska 12a, 10 000, Zagreb, Hrvatska; Model: Stone cement; Mogućnost ugradnje: u razini poda; Mogužnost obrezivanja: Da; OmniClass Number: 23.45.00.00; OmniClass Title: Sanitary, Laundry, and Cleaning Equipment; Type Name: 160 x 90; Web adresa: https://www.aquaestil.hr/hr/proizvodi/tus-kade/42-stone-mm.html; Web adresa2: https://www.aquaestil.hr/hr/proizvodi/tus-kade/43-stone-mm.html
Other(Type) - Category: Plumbing Fixtures; Family Name: Tus kada_ Stone_cement_rezana_R18
